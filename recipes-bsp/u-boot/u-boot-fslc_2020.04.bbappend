FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}"

SRC_URI += "file://0001-cuboxi-Change-part-uuid-mmc-from-0-to-1.patch"
